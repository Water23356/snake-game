# Keil uVision project displayer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: displayer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HC595Handler.a51 Displayer.a51 Queue.a51 Main.a51 Game.a51 Timer.a51 Test.a51 common.inc InputListener.a51 Random.a51 BCDHandler.a51
